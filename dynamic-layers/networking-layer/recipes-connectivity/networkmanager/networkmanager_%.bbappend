RPROVIDES:${PN} += "network-configuration"
RPROVIDES:${PN}-daemon += "network-configuration"
