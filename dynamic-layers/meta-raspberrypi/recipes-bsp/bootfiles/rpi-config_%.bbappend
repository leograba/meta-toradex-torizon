ENABLE_UART:raspberrypi5 = "1"
DISABLE_RPI_BOOT_LOGO:raspberrypi5 = "1"
